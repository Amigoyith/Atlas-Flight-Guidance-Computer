# IAR project Atlas.ewp, settings and files
configuration Atlas (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H743xx; ATLAS_USE_FREERTOS=1
  ICCARM.CCIncludePath2: ../App/Inc; ../ThirdParty/Fusion/Fusion; ../ThirdParty/FreeRTOS-Kernel/include; ../ThirdParty/FreeRTOS-Kernel/portable/IAR/ARM_CM7/r0p1; ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../FATFS/Target; ../FATFS/App; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/Third_Party/FatFs/src; ../App/CubeOverrides/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Atlas.hex
  ILINK.IlinkOutputFile: Atlas.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/Atlas Drivers
    ../App/Src/: atlas_adxl375.c atlas_ble.c atlas_board.c atlas_boot.c atlas_buzzer.c atlas_canard.c atlas_canard_fusion.c atlas_clock_map.c atlas_gnss.c atlas_imu_stream.c atlas_led.c atlas_lsm6dsv16b.c atlas_mmc5983ma.c atlas_ms5611.c atlas_analog.c atlas_io.c atlas_stabilization.c atlas_expansion.c atlas_pyro_policy.c atlas_rfd900x.c atlas_radio_link.c atlas_telemetry.c atlas_telemetry_boot.c atlas_rtos.c atlas_rtos_policy.c atlas_sample_ring.c atlas_sd.c atlas_spi_device.c atlas_status.c atlas_time.c atlas_storage.c atlas_bringup.c atlas_bringup_protocol.c atlas_usb.c atlas_usb_cdc.c atlas_uart_transport.c
    ./: atlas_boot_branch.s
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
    ../App/CubeOverrides/FATFS/Target/: sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../App/CubeOverrides/USB_DEVICE/Target/: usbd_conf.c
  group ThirdParty/Fusion AHRS
    ../ThirdParty/Fusion/Fusion/: FusionAhrs.c
  group ThirdParty/FreeRTOS Kernel
    ../ThirdParty/FreeRTOS-Kernel/: list.c queue.c stream_buffer.c tasks.c
    ../ThirdParty/FreeRTOS-Kernel/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Device_Library
    ../App/CubeOverrides/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../App/CubeOverrides/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
